FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
IMAGE_CLASSES:append:aspeed-g7 = " image_types_phosphor_aspeed_g7"
